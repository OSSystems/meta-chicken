# Copyright (C) 2016 O.S. Systems Software LTDA.

TOOLCHAIN_HOST_TASK_append = " chicken-cross-canadian-${TRANSLATED_TARGET_ARCH}"
