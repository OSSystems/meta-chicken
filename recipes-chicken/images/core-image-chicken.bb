inherit core-image populate_sdk_chicken

CORE_IMAGE_EXTRA_INSTALL += " \
    chicken \
"
